<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32f429IGT6_testingboards.ewp</path>
  </project>
  <batchBuild />
</workspace>
